# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Hardware;..\Third_Party;..\Hardware\VL53L0X\core\inc;..\Hardware\VL53L0X\platform\inc;..\Hardware\VL53L0X;..\Third_Party\fat_fs\inc;..\Third_Party\lvgl;..\Third_Party\lvgl\src;..\Third_Party\lvgl\src\extra;..\Third_Party\lvgl\src\extra\themes\default;..\Third_Party\lvgl\examples\porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_rtc.c gd32f4xx_pmu.c gd32f4xx_fwdgt.c gd32f4xx_wwdgt.c gd32f4xx_i2c.c gd32f4xx_adc.c gd32f4xx_spi.c gd32f4xx_sdio.c
  group Hardware
    ../Hardware/: i2c_oled.c spi_oled.c servo.c vl53l0x.c sdcard.c
    ../Hardware/st7789/: st7789.c
    ../Hardware/cst816/: cst816t.c
  group Hardware/VL53L0X
    ../Hardware/VL53L0X/: bsp_VL53L0X.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
    ../Hardware/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../Hardware/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
  group Library
    ../Library/: USART.c EXTI.c Timer.c GPIO.c DMA.c RTC.c WDGT.c I2C.c ADC.c SPI.c
  group Third_Party/u8g2
    ../Third_Party/u8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_stdio.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Third_Party/fatfs
    ../Third_Party/fat_fs/src/: diskio.c fattime.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group Third_Party/lvgl/core
    ../Third_Party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Third_Party/lvgl/draw
    ../Third_Party/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Third_Party/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Third_Party/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Third_Party/lvgl/extra
    ../Third_Party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Third_Party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Third_Party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Third_Party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Third_Party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Third_Party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Third_Party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Third_Party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Third_Party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Third_Party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Third_Party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Third_Party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Third_Party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Third_Party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Third_Party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Third_Party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Third_Party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Third_Party/lvgl/src/extra/others/msg/: lv_msg.c
    ../Third_Party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Third_Party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Third_Party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Third_Party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Third_Party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Third_Party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Third_Party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Third_Party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Third_Party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Third_Party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Third_Party/lvgl/src/extra/widgets/led/: lv_led.c
    ../Third_Party/lvgl/src/extra/widgets/list/: lv_list.c
    ../Third_Party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Third_Party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Third_Party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Third_Party/lvgl/src/extra/widgets/span/: lv_span.c
    ../Third_Party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Third_Party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Third_Party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Third_Party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Third_Party/lvgl/src/extra/widgets/win/: lv_win.c
    ../Third_Party/lvgl/src/extra/: lv_extra.c
  group Third_Party/lvgl/font
    ../Third_Party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Third_Party/lvgl/gpu
    ../Third_Party/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Third_Party/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Third_Party/lvgl/hal
    ../Third_Party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Third_Party/lvgl/misc
    ../Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Third_Party/lvgl/widgets
    ../Third_Party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Third_Party/lvgl/example/porting
    ../Third_Party/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
